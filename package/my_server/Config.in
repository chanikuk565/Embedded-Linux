## package/server/server/Config.in
```kconfig
config BR2_PACKAGE_SERVER
    bool "my server"
    help
        server package.

        https://server.xyz
```
